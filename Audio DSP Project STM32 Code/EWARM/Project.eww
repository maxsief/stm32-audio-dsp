<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Audio DSP Project STM32 Code.ewp</path>
  </project>
  <batchBuild />
</workspace>
